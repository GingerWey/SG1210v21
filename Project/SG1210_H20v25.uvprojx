# Keil uVision project SG1210_H20v25.uvprojx, settings and files
target APP (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SG1210_H21v2.33.2532
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,__FPU_PRESENT=1U,ARM_MATH_CM4,__DEBUG
  c include: ..\Application;..\Application\Config;..\Application\COM;..\Application\Device;..\Application\GUI;..\Application\Mics;..\Application\System;..\Application\Tasks;..\Drivers\Cube\inc;..\Drivers\CMSIS\Include;..\Drivers\HAL_Driver\Inc;..\Drivers\HAL_Driver\Inc\Legacy;..\Drivers\Peripherals;..\Middlewares\emWin\include;..\Middlewares\emWin\user;..\Middlewares\emWin\fonts;..\Middlewares\FreeRTOS;..\Middlewares\FreeRTOS\CMSIS_RTOS_V2;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\ARM_CM4F_GCC;..\Middlewares\emWin\csgimage;..\Middlewares\emWin\csgimage\Compress;..\Application\GUI\Graphics
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application
    ../Application/: main.cpp
  group Application/Tasks
    ../Application/Tasks/: TaskApp.cpp TaskCtrl.cpp TaskHMI.cpp TaskUart.cpp
  group Application/Device
    ../Application/Device/: CoilCtrl.cpp DFT80.cpp NumProc.cpp SamplesProc.cpp WaveLogger.cpp
  group Application/Misc
    ../Application/Mics/: AES128.cpp CRC1632.cpp RamHeap.cpp RNGen.cpp MidAvgFilter.cpp
  group System/Core
    ../Application/System/: DevBuffer.cpp DevChkSelf.cpp DevClock.cpp DevDebug.cpp DevFixed.cpp DevEvtMgr.cpp DevFunc.cpp DevIntf.cpp DevRegInfo.cpp DevRegInfoList.cpp DevRegs.cpp FuncUVTC.cpp Retarget.cpp
    ../Application/System/Strings/: TextStrs.cpp
  group COMM
    ../Application/COM/: COMBuffer.cpp COMDevIntf.cpp COMRingBuf.cpp EchoSvr.cpp InspSvr.cpp Protocol.cpp SocketBase.cpp SocketUART.cpp proModbusRTUSlave.cpp
  group GUI
    ../Application/GUI/: GUICntr.cpp GFormCentra.cpp GUIEditors.cpp GUIMisc.cpp PictureRes.cpp
    ../Middlewares/emWin/user/: GUIBitmap.h GUIBitmap.c GUIPicture.cpp
  group GUI/Form
    ../Application/GUI/: GSplashForm.cpp GMainForm.cpp GMenuForm.cpp GDataListForm.cpp GLogListForm.cpp GConfigForm.cpp GDevInfoForm.cpp GGuageForm.cpp GLoginDialog.cpp GTimeDialog.cpp GMessageForm.cpp GUICtrlConfigDialog.cpp GUIUARTConfigDialog.cpp GFatalForm.cpp
  group GUI/CSG
    ../Application/GUI/: CSGDraw.cpp
    ../Middlewares/emWin/csgimage/: BitPacker.cpp BitPacker.h CSGCodec.cpp CSGCodec.h CSGCommon.cpp CSGCommon.h CSGDecoder.cpp CSGDecoder.h
    ../Middlewares/emWin/csgimage/Compress/: CompressionBase.cpp CompressionBase.h Huffman.cpp Huffman.h MiniLZ77.cpp MiniLZ77.h RLE.cpp RLE.h
  group Drivers/Cube
    ../Drivers/Cube/Src/: adc.c crc.c dma.c fsmc.c gpio.c iwdg.c rtc.c spi.c tim.c usart.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/: system_stm32f4xx.c startup_stm32f407xx.s
    ../Drivers/CMSIS/: arm_cortexM4lf_math.lib
  group Drivers/HAL
    ../Drivers/HAL_Driver/: HAL_STM32F4v182.lib
  group Drivers/Peripherals
    ../Drivers/Peripherals/: ADCMgr.cpp BoardCtrl.cpp DIO.cpp Flash_if.cpp I2CBus.cpp INA226.cpp IndLED.cpp KeyBoard.cpp MB85RSxx.cpp MCP401x.cpp NvRAM.cpp SD3077.cpp SPIChls.cpp SPIFlash.cpp UartChls.cpp
  group emWin
    ../Middlewares/emWin/user/: GUI_X_FreeRTOS.c GUIConf.c LCDConf.c ST7789S.c
    ../Middlewares/emWin/fonts/: GUI_UC_Font.c
  group emWin/Lib
    ../Middlewares/emWin/fonts/: GUI_UC_EncodeNoneX.c
    ../Middlewares/emWin/: GUI_CM4F_L.lib
  group emWin/Fonts
    ../Middlewares/emWin/fonts/: FontCHS16LTH.cpp FontCHS24LTH.cpp Font_ASCCAP24B.cpp Font_AA4_16_B.c FontASCII16.cpp
    ../Application/GUI/Graphics/: ImageRes.cpp ImageRes.h
  group FreeRTOS
    ../Middlewares/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c CCMHeap.c
    ../Middlewares/FreeRTOS/portable/ARM_CM4F_GCC/: port.c
